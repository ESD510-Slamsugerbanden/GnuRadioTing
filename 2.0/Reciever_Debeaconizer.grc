options:
  parameters:
    author: admin
    generate_options: qt_gui
    id: Reciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 80e3*4
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*10e3)
    maxoutbuf: '512'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    maxoutbuf: '1024'
    quad_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 15e3
    low_cutoff_freq: 5e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.5'
    mintime: '2000.0'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import uhd
      from numba import njit
      import RPi.GPIO as GPIO



      Pin1 = 17
      Pin2 = 27
      Pin_led = 0
      def setup():
          GPIO.setmode(GPIO.BCM)
          GPIO.setup(Pin1, GPIO.OUT)
          GPIO.setup(Pin2, GPIO.OUT)
          GPIO.output(Pin1, GPIO.LOW)
          GPIO.output(Pin2, GPIO.LOW)
          GPIO.setup(Pin_led, GPIO.OUT)
          GPIO.output(Pin_led, GPIO.LOW)

      def set_switch(sw):
          
          match sw:
              case 1:
                  GPIO.output(Pin1, GPIO.LOW)
                  GPIO.output(Pin2, GPIO.LOW)
              
              case 0:
                  GPIO.output(Pin1, GPIO.HIGH)
                  GPIO.output(Pin2, GPIO.LOW)
              
              case 3:
                  GPIO.output(Pin1, GPIO.LOW)
                  GPIO.output(Pin2, GPIO.HIGH)
              

              case 2:
                  GPIO.output(Pin1, GPIO.HIGH)
                  GPIO.output(Pin2, GPIO.HIGH)




      ######################################################
      # RØV LANG OG TRÆLS KODE FOR AT LAVE NOGLE GOLDCODES # xoxo Malther
      ######################################################


      def lfsr_sequence(poly, seed, n):
          """Generate an m-sequence using given feedback polynomial (as taps)."""
          state = seed.copy()
          seq = np.zeros(2**n - 1, dtype=int)
          for i in range(len(seq)):
              seq[i] = state[-1]
              feedback = np.mod(np.sum(state[np.array(poly) - 1]), 2)
              state[1:] = state[:-1]
              state[0] = feedback
          return seq

      def gold_codes(n, poly1, poly2, seed):
          """Generate Gold code family for degree n LFSRs with given feedback taps."""
          s1 = lfsr_sequence(poly1, seed.copy(), n)
          s2 = lfsr_sequence(poly2, seed.copy(), n)
          N = len(s1)
          codes = []

          for shift in range(N):
              s2_shift = np.roll(s2, shift)
              codes.append(np.bitwise_xor(s1, s2_shift))
          # Add original sequences too
          codes.append(s1)
          codes.append(s2)
          return np.array(codes)


      def auto_generate(my_id):
          """Generate codes using predefined settings"""
          n = 5
          poly1 = [5, 2]          # x^5 + x^2 + 1
          poly2 = [5, 4, 3, 2]    # x^5 + x^4 + x^3 + x^2 + 1
          seed = np.array([1, 0, 0, 0, 1])

          codes = gold_codes(n, poly1, poly2, seed)
          return np.float32(codes[my_id])



      @njit
      def numba_kernel(input, buffer, mycode, corr_thres):
          N = len(input)
          output = np.empty(N, dtype=np.float32)

          i_maxcorr = -1
          maxcorr = 0.0
          peakflag = False

          for i in range(N):
              for k in range(len(buffer)-1, 0, -1):
                  buffer[k] = buffer[k-1]
              buffer[0] = input[i]

              corr = np.dot(buffer, mycode) / len(buffer)

              output[i] = corr

              val = abs(corr)
              if val > corr_thres:
                  maxcorr = corr
                  i_maxcorr = i
                  peakflag = True

          return output, peakflag, maxcorr, i_maxcorr



      SW0 = 0x10
      SW1 = 0x20
      SW2 = 0x40
      SW3 = 0x80


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, burst_period=100,bursts = 4, gold_code=1, sps=3, minislot_delay=50, correlation_threshold=0.05):  # only default arguments here
              """Jydesnak DE-beaconizer"""
              gr.sync_block.__init__(
                  self,
                  name='Jydesnak DE-BEACONIZER',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32],
              )
              self.message_port_register_out(pmt.intern("Corr OUT"))
              self.burst_period = burst_period ##How often we expect the beacon to repeat itself
              self.bursts = bursts #How many bursts we expect pr beacon
              self.sps= sps #Samples per symbol
              self.mycode = np.subtract(np.repeat(auto_generate(gold_code), self.sps) * 2 , 1)##Genererer vores SCHLONG vektor der kan bruges
              self.mycode = np.flip(self.mycode) #FLips to match what we expect in out buffer
              self.vectorlength = len(self.mycode) #Length of the vector in samples
              self.buffer = np.zeros(self.vectorlength, dtype=np.float32)
              self.rssi_buffer = np.zeros(int(self.vectorlength * 1.2), dtype=np.float32)
              self.rssi_est_buffer = np.zeros(4, dtype=np.float32)
              
              self.correlation_threshold = correlation_threshold
              self.maxcorr = 0
              self.i_maxcorr = 0
              ###STUFF for locking onto our target in time
              self.minislot = int(self.vectorlength/4)
              self.set_max_output_buffer(0, self.minislot)
              self.T_search = int(self.minislot*6) 
              self.switch_number = 0
              self.usrp = None
              self.cooldown = 0 
              self.minislot_delay = minislot_delay
              self.locks = 0
              self.corrbuffer = np.zeros(4)    
              

          def start(self):
              print(f"[DE-beaconizer]: minislot: {self.minislot}, \t burst period: {self.burst_period}")
              # trigger JIT compile
              numba_kernel(np.zeros(1, np.float32),
                           self.buffer,
                           self.mycode,
                           self.correlation_threshold)
              self.usrp = uhd.usrp.MultiUSRP() ##Finder den første og den bedste USRP
              self.usrp.set_gpio_attr("FP0", "DDR", 0xFF, 0xF0) ##Sætter alle GPIO'er som output
              self.usrp.set_gpio_attr("FP0", "CTRL", 0x00, 0xF0)
              
              
              setup()
              set_switch(1)
              return True



          def work(self, input_items, output_items):
              inp = input_items[0]
              
              in_pwr = input_items[1]

              rssi_len = int(len(in_pwr))
              self.rssi_buffer = np.roll(self.rssi_buffer, rssi_len)        
              self.rssi_buffer[:rssi_len] = in_pwr


              out = output_items[0]
              N = len(out)




              # Call compiled kernel
              output, peakflag, maxcorr, i_maxcorr = numba_kernel(
                  inp, 
                  self.buffer,
                  self.mycode,
                  self.correlation_threshold
              )

              out[:] = output

              self.cooldown -= N

              # Handle tagging
              if peakflag and self.cooldown <= 0:
                  self.cooldown = self.vectorlength / 2
                  self.corrbuffer = np.roll(self.corrbuffer,  1)
                  self.corrbuffer[0] = maxcorr



                  ##Vi har set et peak
                  key   = pmt.intern("suspekt")
                  value = pmt.from_float(maxcorr)
                  offset = self.nitems_written(0) + int(i_maxcorr)
                  self.add_item_tag(0, offset, key, value)

                  #Så vi noterer lige hvad RSSI var på det gældende tidspunkt
                  self.rssi_est_buffer = np.roll(self.rssi_est_buffer, 1)
                  self.rssi_est_buffer[0] = np.sum(self.rssi_buffer)

                  ##Skriver ud at vi skifter switchen
                  key   = pmt.intern("SW")
                  value = pmt.from_long(int(self.switch_number))
                  offset = self.nitems_written(0) + int(N)
                  self.add_item_tag(0, offset, key, value)
                  if(self.switch_number == 0):
                      GPIO.output(Pin_led, GPIO.HIGH)

                      key   = pmt.intern("TRIG")
                      value = pmt.from_long(int(self.locks))
                      offset = self.nitems_written(0) + int(N)
                      self.add_item_tag(0, offset, key, value)
                      
                      if np.all(np.multiply(self.corrbuffer, [1, -1, -1, 1]) > 0):
                          self.locks += 1
                      else:
                          self.locks = 0

                  
                  if(self.switch_number == 3 and self.locks > 5):
                      pmt_msg = pmt.make_dict()
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("CH0"), pmt.from_float(float(self.corrbuffer[0])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("CH1"), pmt.from_float(float(self.corrbuffer[1])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("CH2"), pmt.from_float(float(self.corrbuffer[2])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("CH3"), pmt.from_float(float(self.corrbuffer[3])))
                      
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("RSSI0"), pmt.from_float(float(self.rssi_est_buffer[0])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("RSSI1"), pmt.from_float(float(self.rssi_est_buffer[1])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("RSSI2"), pmt.from_float(float(self.rssi_est_buffer[2])))
                      pmt_msg = pmt.dict_add(pmt_msg, pmt.intern("RSSI3"), pmt.from_float(float(self.rssi_est_buffer[3])))
                      
                      
                      
                      pmt_msg = pmt.dict_add(
                          pmt_msg,
                          pmt.intern("Locks"),
                          pmt.from_float(float(self.locks))
                      )
                      GPIO.output(Pin_led, GPIO.LOW)

                      self.message_port_pub(pmt.intern("Corr OUT"), pmt_msg)

                  if(maxcorr < 0 and (self.switch_number == 2 or self.switch_number == 3)):
                      self.switch_number = (self.switch_number +1) % 4
                  if(maxcorr > 0 and (self.switch_number == 0 or self.switch_number == 1)):
                      self.switch_number = (self.switch_number +1) % 4


                  set_switch(self.switch_number)
                  
              return N
    burst_period: '800'
    bursts: '4'
    correlation_threshold: '0.9'
    gold_code: '1'
    minislot_delay: '50'
    sps: '20'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Port: '8700'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import gr
      import pmt
      import socket as sock
      import struct




      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Port=8700):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MSQ UDP sink',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("MSG in"))

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.port = Port
              self.set_msg_handler(pmt.intern("MSG in"), self.handle_msg)
              self.sock = sock.socket(sock.AF_INET, sock.SOCK_DGRAM)
              


          def handle_msg(self, msg):
              if pmt.is_dict(msg):
                  
                  keys = ["CH0", "CH1", "CH2", "CH3"]
                  ch = np.zeros(4, dtype=np.float32)
                  
                  keys = ["RSSI0", "RSSI1", "RSSI2", "RSSI3"]
                  rssi = np.zeros(4, dtype=np.float32)


                  buf = bytes()
                  for i in range(len(keys)):
                      ch[i] = pmt.dict_ref(msg, keys[i], pmt.PMT_NIL)
                      buf += struct.pack("f", ch[i])
                  
                  for i in range(len(keys)):
                      rssi[i] = pmt.dict_ref(msg, keys[i], pmt.PMT_NIL)
                      buf += struct.pack("f", rssi[i])


                  locks = pmt.dict_ref(msg, "Locks", pmt.PMT_NIL)
                  buf += struct.pack("f", ch[i])            
                  print(f"Send UDP package len={len(buf)}")
                  self.sendto(buf, ("127.0.0.1", self.port))

              pass


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              
              
              
              
              return len(output_items[0])
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 30e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '0.4'
    alpha3: '0.5'
    label1: GoldCode corr
    label2: RAW FM-Demod
    label3: Raw sample (Real)
    nconnections: '3'
    size: 8192*4
    srate: samp_rate
    tr_delay: '0.01'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"TRIG"'
    type: float
    update_time: '0.02'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: int(2.49e9)
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '2']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '1']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [epy_block_0, '0', blocks_probe_rate_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, Corr OUT, blocks_message_debug_0, print]
- [epy_block_0, Corr OUT, epy_block_1, MSG in]
- [low_pass_filter_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
