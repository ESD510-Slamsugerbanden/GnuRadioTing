options:
  parameters:
    author: sennels
    generate_options: no_gui
    id: Transfrans
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Base_samp_rate
  id: variable
  parameters:
    value: Symbol_rate*samples_pr_sym
  states: {}
- name: FFT_bins
  id: variable
  parameters:
    value: '256'
  states: {}
- name: PI
  id: variable
  parameters:
    value: '3.14159265358979323'
  states: {}
- name: Symbol_rate
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samples_pr_sym
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sep_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: sep_freq+1000
    low_cutoff_freq: sep_freq-1000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '8000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: FFT_bins
    type: float
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: FFT_bins
    frame_rate: Base_samp_rate
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: FFT_bins*4
    port: '5006'
    send_eof: 'False'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    grid: 'True'
    vlen: FFT_bins
    x_start: '0'
    x_step: '1.0'
    ymax: '-30'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '2490000000'
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0_0_0, '0', logpwrfft_x_0, '0']
- [blocks_vector_to_stream_1, '0', network_udp_sink_0, '0']
- [logpwrfft_x_0, '0', blocks_vector_to_stream_1, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
