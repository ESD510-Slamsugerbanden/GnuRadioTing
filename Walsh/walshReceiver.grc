options:
  parameters:
    author: sennels
    generate_options: qt_gui
    id: Transfrans
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Base_samp_rate
  id: variable
  parameters:
    value: Symbol_rate*samples_pr_sym
  states: {}
- name: FFT_bins
  id: variable
  parameters:
    value: '32'
  states: {}
- name: PI
  id: variable
  parameters:
    value: '3.14159265358979323'
  states: {}
- name: Symbol_rate
  id: variable
  parameters:
    value: (31)*64
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samples_pr_sym
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sep_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: toggle_amplitude
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Transmit
    outputmsgname: toggle_amplitude
    pressed: '1'
    released: '0'
    type: real
    value: '1'
  states: {}
- name: toggle_invert
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Invert
    outputmsgname: toggle_amplitude
    pressed: '1'
    released: '-1'
    type: real
    value: '-1'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*sep_freq)
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: sep_freq+1000
    low_cutoff_freq: sep_freq-1000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '8000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: sep_freq+1000
    low_cutoff_freq: sep_freq-1000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '8000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: toggle_invert
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sep_freq
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: toggle_amplitude
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int((samp_rate)/(Symbol_rate))
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*PI
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '31'
    type: float
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '5'
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Takes a scalar input and outputs a scaled vector."""

          def __init__(self, chip_vector=[-1, -1, -1, -1, -1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, -1, -1, -1, 1, 1, 1]):

              self.chip_vector = np.array(chip_vector, dtype=np.float32)

              gr.sync_block.__init__(
                  self,
                  name='Scalar to Vector Block',
                  in_sig=[np.float32],                     # Single float input per item
                  out_sig=[(np.float32, len(chip_vector))] # Vector output per item
              )

          def work(self, input_items, output_items):
              x = input_items[0]           # shape: (ninput_items,)
              out = output_items[0]        # shape: (ninput_items, len(chip_vector))
              out[:] = x[:, np.newaxis] * self.chip_vector
              return len(out)
    chip_vector: (-1, -1, -1, -1, -1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, -1, -1, -1, 1, 1, 1)
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: 5*4
    port: '5006'
    src_zeros: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Quadrature decoder"'
    size: int((samp_rate)/(Symbol_rate))*31
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Quadrature decoder"'
    size: int(31*samples_pr_sym)*2
    srate: Base_samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: Base_samp_rate
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [band_pass_filter_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [band_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_1, '0']
- [band_pass_filter_0_0_0_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vco_c_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_vco_c_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_repeat_0, '0']
- [channels_channel_model_0, '0', band_pass_filter_0_0_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [network_udp_source_0, '0', epy_block_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
