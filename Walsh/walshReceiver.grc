options:
  parameters:
    author: sennels
    generate_options: qt_gui
    id: Transfrans
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Base_samp_rate
  id: variable
  parameters:
    value: Symbol_rate*samples_pr_sym
  states: {}
- name: PI
  id: variable
  parameters:
    value: '3.14159265358979323'
  states: {}
- name: Symbol_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samples_pr_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sep_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: sep_freq+5000
    low_cutoff_freq: sep_freq-5000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '8000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: logpwrfft_x_0_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1'
    fft_size: '256'
    frame_rate: Base_samp_rate
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: network_udp_sink_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: '5006'
    send_eof: 'False'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '256'
    x_start: '0'
    x_step: '1.0'
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    int_max: '0'
    int_min: '-110'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '2490000000'
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0_0, '0', logpwrfft_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', network_udp_sink_1, '0']
- [logpwrfft_x_0_0, '0', blocks_vector_to_stream_0, '0']
- [logpwrfft_x_0_0, '0', qtgui_vector_sink_f_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
