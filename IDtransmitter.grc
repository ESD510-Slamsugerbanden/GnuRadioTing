options:
  parameters:
    author: Tueha
    generate_options: qt_gui
    id: shit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ID
  id: variable
  parameters:
    value: 1,1,-1,-1,1,-1,1,-1
  states: {}
- name: PI
  id: variable
  parameters:
    value: '3.14159265358979323'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: '8'
  states: {}
- name: packet_rate
  id: variable_qtgui_entry
  parameters:
    label: Packet sample rate
    type: real
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sep_freq
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_burst_to_stream_0
  id: blocks_burst_to_stream
  parameters:
    len_tag_key: '"packet_len"'
    propagate_tags: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_f32vector(8, ID))
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sep_freq
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interp
    type: float
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: interp
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2*PI
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '0.002'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 30e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2.49e9
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.49e9
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_burst_to_stream_0, '0', blocks_add_xx_0, '0']
- [blocks_message_strobe_0_0, strobe, pdu_pdu_to_tagged_stream_0_0, pdus]
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_vco_c_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_burst_to_stream_0, '0']
- [blocks_vco_c_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
